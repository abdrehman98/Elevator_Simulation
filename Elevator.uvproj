# Keil uVision project Elevator.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C1051 Atmel
  cpu: IRAM(0 - 0x3F) IROM(0 - 0x3FF) CLOCK(24000000)
  output: Elevator +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 code.c
